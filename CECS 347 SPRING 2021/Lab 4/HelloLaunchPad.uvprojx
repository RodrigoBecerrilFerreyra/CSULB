# Keil uVision project HelloLaunchPad.uvprojx, settings and files
target HelloLaunchPad (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HelloLaunchPad +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;C:\Program Files (x86)\Keil uVision 5 ARM\TExaSware;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s main.c ADCSWTrigger.c PLL.c Nokia5110.c
software components: CMSIS:CORE 5.4.0
